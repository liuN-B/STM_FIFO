# Keil uVision project test.uvprojx, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\MultiButton;.\MultiTimer
  group Source Group 1
    ./: STARTUP.A51
  group APP
    ./: test_stc15f104w.c
  group Package
    ./MultiTimer/: multi_timer.c
